Commit message: newest version

File: resources/IAI_kitchen.urdf (robot description, URDF)
Before this commit: robot iai_oven_area, 60 links, 59 joints
Joints:
- joint iai_fridge_door_joint: type revolute -> fixed
